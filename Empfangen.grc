options:
  parameters:
    generate_options: qt_gui
    id: Empfangen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: variable_qtgui_toggle_switch_0
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    position: '3'
    pressed: '1'
    released: '0'
    switchOffBackground: black
    type: int
    value: '0'
  states: {}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: blocks_swapiq_1
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '16000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_swapiq_0, '0', high_pass_filter_0, '0']
- [blocks_swapiq_1, '0', low_pass_filter_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', blocks_swapiq_0, '0']
- [rtlsdr_source_0, '0', blocks_swapiq_1, '0']
- [variable_qtgui_toggle_switch_0, state, rtlsdr_source_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
